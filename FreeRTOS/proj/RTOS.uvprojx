# Keil uVision project RTOS.uvprojx, settings and files
target Target 1 (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F373CC STMicroelectronics
  pack: Keil.STM32F3xx_DFP.1.2.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: RTOS
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F37X,
  c misc: --c99
  c include: ..\inc;..\main;..\..\Libraries\CMSIS\Device\ST\STM32F37x\Include;..\..\Libraries\CMSIS\Include;..\..\Libraries\STM32F37x_StdPeriph_Driver\inc;..\..\Third_Party\FreeRTOS\Source\include;..\..\Third_Party\FreeRTOS\Source\CMSIS_RTOS;..\..\Third_Party\FreeRTOS\Source\portable\RVDS\ARM_CM4F
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group startup
    ../../Libraries/CMSIS/Device/ST/STM32F37x/Source/Templates/arm/: startup_stm32f37x.s
  group main
    ../main/: main.c stm32f37x_it.c system_stm32f37x.c
  group board
    ../src/: LED.c cpu_utils.c UART.c
  group periph
    ../../Libraries/STM32F37x_StdPeriph_Driver/src/: stm32f37x_gpio.c stm32f37x_misc.c stm32f37x_rcc.c stm32f37x_syscfg.c stm32f37x_usart.c
  group FreeRTOS
    ../../Third_Party/FreeRTOS/Source/: croutine.c list.c queue.c tasks.c timers.c
  group FreeRTOS/Portable
    ../../Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
    ../../Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
