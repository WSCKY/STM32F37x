# Keil uVision project LED.uvprojx, settings and files
target target (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F373CC STMicroelectronics
  pack: Keil.STM32F3xx_DFP.1.2.0
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: LED
  AfterMake: D:\MDK\install\ARM\ARMCC\bin\fromelf.exe --bin -o .\test.bin .\Objects\LED.axf
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F37X,
  c misc: --cpp11
  c include: ..\main;..\..\Libraries\STM32F37x_StdPeriph_Driver\inc;..\..\Libraries\CMSIS\Include;..\..\Libraries\CMSIS\Device\ST\STM32F37x\Include;..\inc
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group startup
    ../../Libraries/CMSIS/Device/ST/STM32F37x/Source/Templates/arm/: startup_stm32f37x.s
  group main
    ../main/: main.c stm32f37x_it.c system_stm32f37x.c
  group board
    ../src/: LED.c
  group periph
    ../../Libraries/STM32F37x_StdPeriph_Driver/src/: stm32f37x_gpio.c stm32f37x_misc.c stm32f37x_rcc.c stm32f37x_syscfg.c
