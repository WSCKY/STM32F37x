# Keil uVision project PID.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F373CC STMicroelectronics
  pack: Keil.STM32F3xx_DFP.1.2.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: PID
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F37X,__FPU_PRESENT=1,__FPU_USED =1,ARM_MATH_CM4,__CC_ARM
  c misc: --c99
  c include: ..\inc;..\main;..\..\Libraries\CMSIS\Device\ST\STM32F37x\Include;..\..\Libraries\CMSIS\Include;..\..\Libraries\STM32F37x_StdPeriph_Driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group startup
    ../main/: startup_stm32f37x.s
  group main
    ../main/: main.c stm32f37x_it.c system_stm32f37x.c
  group board
    ../src/: Delay.c IMU.c TIMCounter.c UART_IT.c MyPID.c PWM.c TIM2_IT.c ADC.c DataMonitor.c LED.c MPU6050_IIC.c DataTransfer.c Control.c
    ../../Libraries/STM32F37x_StdPeriph_Driver/src/: stm32f37x_dma.c
  group periph
    ../../Libraries/STM32F37x_StdPeriph_Driver/src/: stm32f37x_gpio.c stm32f37x_misc.c stm32f37x_rcc.c stm32f37x_syscfg.c stm32f37x_tim.c stm32f37x_usart.c stm32f37x_adc.c stm32f37x_crc.c stm32f37x_i2c.c
  group FPULIB
    ../../Libraries/CMSIS/FPU/: arm_cortexM4lf_math.lib
